# Keil uVision project Template.uvprojx, settings and files
target ACAE01 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER, USE_STM324xG_EVAL,STM32F4XX,
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\RTC;..\W5300_TEST;..\HARDWARE\ADC;..\USMART;..\HARDWARE\SRAM;..\HARDWARE\TIMER;..\MYHEADER;..\HARDWARE\FRAM_IIC2;..\HARDWARE\FRAM;..\HARDWARE\SMBus;..\HARDWARE\IIC3_YJ;..\STM32_CPAL_DRIVE;..\STM32_CPAL_DRIVE\STM32_CPAL_Driver\inc;..\STM32_CPAL_DRIVE\STM32_CPAL_Driver\devices\stm32f4xx;..\STM32_CPAL_DRIVE\Utilities\STM32_EVAL\Common;..\STM32_CPAL_DRIVE\Utilities\STM32_EVAL_CPAL\Common;..\STM32_CPAL_DRIVE\Utilities\STM32_EVAL\STM3240_41_G_EVAL
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group MYHEADER
    ../MYHEADER/: GlobalVars.h ExGlobalVars.h MyMath.h
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/FRAM/: FRAM.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/FRAM_IIC2/: FRAM_IIC2.c
    ../HARDWARE/ADC/: adc.c
  group README
    ../README/: README.txt
  group STM32_CPAL_DRIVE
    ../STM32_CPAL_DRIVE/: cpal_usercallback.c I2C3_Master.c
    ../STM32_CPAL_DRIVE/STM32_CPAL_Driver/src/: cpal_hal.c cpal_i2c.c
    ../STM32_CPAL_DRIVE/STM32_CPAL_Driver/devices/stm32f4xx/: cpal_i2c_hal_stm32f4xx.c
